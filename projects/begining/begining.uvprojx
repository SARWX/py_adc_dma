# Keil uVision project begining.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: begining +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
software components: Device:Startup 2.1.0i, Drivers:PORT 2.0.3i, Drivers:RST_CLK 2.0.3i
